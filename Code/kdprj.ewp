# IAR project kdprj.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x100
  General.SCCStackSize: 0x200
  General.SCRStackSize: 0x200
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x60
  General.SCCStackSize: 0x190
  General.SCRStackSize: 0x190
  group (top)
    ./: bitbyt.h ds1990a.h eeprom.h kedahm.c kedahm.h madelay.h portdefines.h
